Commit message: Added moveit configuration

File: oro_v6/urdf/oro_v6.urdf (robot description, URDF)
Before this commit: robot oro, 12 links, 11 joints
Links:
- link base_link: mass None -> 0.1
